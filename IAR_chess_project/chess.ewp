# IAR project chess.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: chess.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c std_types.h
  group CHESS
    ./: chess.c chess_config.h Chess_interface.h
  group GPIO
    ../Drivers/GPIO Driver/: GPIO_interface.h GPIO_private.h GPIO_prog.C
    ./: macros.h
  group PLL
    ./: PLL_interface.h PLL_private.h PLL_prog.c
  group ROBOT
    ./: Robot.c robot_config.h Robot_interface.h
  group startup
    ./: bsp.c startup_tm4c.c tm4c_cmsis.h
  group SYSTICK
    ./: SysTick_interface.h SysTick_Private.h SysTick_prog.c
  group timers
    ./: Timer0_16_PWM_config.h Timer0_16_PWM_interface.h Timer0_16_PWM_private.h Timer0_16_PWM_prog.c Timer0_PWM_config.h Timer0_PWM_interface.h Timer0_PWM_private.h Timer0_PWM_prog.c Timer1_PWM_config.h Timer1_PWM_interface.h Timer1_PWM_private.h Timer1_PWM_prog.c Timer5_PWM_config.h Timer5_PWM_interface.h Timer5_PWM_private.h Timer5_PWM_prog.c
